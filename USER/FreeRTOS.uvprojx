# Keil uVision project FreeRTOS.uvprojx, settings and files
target FreeRTOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\HARDWARE\LED;..\HARDWARE\TIMER;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\DHT22;..\HARDWARE\QLCD;..\HARDWARE\BEEP;..\HARDWARE\NUM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/LCD/: font.h lcd.c lcd.h
    ../HARDWARE/DHT22/: dht22.c dht22.h
    ../HARDWARE/EXTI/: exti.c exti.h
    ../HARDWARE/BEEP/: beep.h beep.c
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/QLCD/: platform_config.h
    ../HARDWARE/NUM/: number.c number.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_dbgmcu.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_exti.c
    ../STM32F10x_FWLib/inc/: stm32f10x_exti.h
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group README
    ../: README.TXT
